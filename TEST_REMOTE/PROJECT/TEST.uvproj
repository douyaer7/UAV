# Keil uVision project TEST.uvproj, settings and files
target TEST (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\BSP;..\LIB;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: stm32f10x_it.c main.c
  group LIB
    ../LIB/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c core_cm3.c misc.c stm32f10x_conf.h stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c
  group BSP
    ../BSP/: LED.c LED.h RCC.c RCC.h USART.c USART.h BSP.c BSP.h AD.c AD.h TIME.c TIME.h DTLOAD.c DTLOAD.h NRF24L01.c NRF24L01.h SPI.c SPI.h
